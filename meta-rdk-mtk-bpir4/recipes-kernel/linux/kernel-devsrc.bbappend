RDEPENDS:${PN}:remove = " gcc-plugins libmpc-dev"
