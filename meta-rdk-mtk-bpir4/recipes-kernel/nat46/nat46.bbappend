LIC_FILES_CHKSUM="file://${COMMON_LICENSE_DIR}/GPL-2.0-only;md5=801f80980d171dd6425610833a22dbe6"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRCREV:kernel6-12 = "9e08da84b6e77c8076d0e4f204af6c29c2c64f6e"
SRC_URI += "file://makefile.patch"
