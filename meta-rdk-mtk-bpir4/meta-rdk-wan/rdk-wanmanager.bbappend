include ccsp_common_bananapi.inc
RDEPENDS_${PN} += "ndisc6"
