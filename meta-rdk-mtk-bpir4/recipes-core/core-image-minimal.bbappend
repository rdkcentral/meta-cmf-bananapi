
MACHINE_FEATURES:remove = "efi"
