SRC_URI:remove = "file://01-dbus-ccsp-apis-1.14.8.patch \
		  "
