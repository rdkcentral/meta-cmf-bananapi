
SRC_URI:remove = "file://0001-add-ENABLE_FEATURE_SYSTEMD-and-use-it-in-syslogd.patch \
           file://busybox-1.31-ping-mdev-support.patch \
	  "
