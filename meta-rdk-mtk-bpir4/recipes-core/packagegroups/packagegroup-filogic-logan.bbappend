RDEPENDS:packagegroup-filogic-logan:remove_onewifi += " iwinfo \
                                             uci \
					ubus \
"
