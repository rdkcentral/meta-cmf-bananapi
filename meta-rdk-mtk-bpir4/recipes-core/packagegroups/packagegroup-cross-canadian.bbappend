GDB:wrynose = ""
GCC:wrynose = ""
BINUTILS:wrynose = ""
do_package[vardeps] += "GDB GCC BINUTILS"
