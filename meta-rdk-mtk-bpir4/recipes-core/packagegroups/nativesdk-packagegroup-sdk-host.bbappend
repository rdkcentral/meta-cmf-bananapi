RDEPENDS:${PN}:remove:wrynose = "nativesdk-bison nativesdk-autoconf nativesdk-automake"
