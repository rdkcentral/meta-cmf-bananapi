RDEPENDS:packagegroup-filogic-mt76:remove:onewifi = " \
                    hostapd \
                    usteer \
                    wifi-test-tool \
                    vts \
"
