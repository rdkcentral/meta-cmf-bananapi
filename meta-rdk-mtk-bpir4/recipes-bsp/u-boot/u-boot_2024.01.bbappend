
UBOOT_CONFIG[mt7622_rfb_defconfig] = "mt7622_rfb_defconfig"
