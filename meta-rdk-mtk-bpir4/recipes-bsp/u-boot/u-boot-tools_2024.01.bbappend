SRC_URI:remove = "file://CVE-2024-57254.patch \
           file://CVE-2024-57255.patch \
           file://CVE-2024-57256.patch \
           file://CVE-2024-57257.patch \
           file://CVE-2024-57258-1.patch \
           file://CVE-2024-57258-2.patch \
           file://CVE-2024-57258-3.patch \
           file://CVE-2024-57259.patch \
	   "

DEPENDS:append = "gnutls"
