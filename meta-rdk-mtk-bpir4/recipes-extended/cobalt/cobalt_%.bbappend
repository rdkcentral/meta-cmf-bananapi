SRCREV_FORMAT = "depot_tools_wayland_cobalt"
