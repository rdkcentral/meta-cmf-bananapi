FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:scarthgap = " file://incomplete_type.patch"
