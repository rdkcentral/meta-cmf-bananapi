FILES:${PN}-dev:remove = "${libdir}/*.so"
