CFLAGS_append = " -D_PLATFORM_BANANAPI_R4_ "
