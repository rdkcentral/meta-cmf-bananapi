SRC_URI:remove:broadband += " file://lighttpd_jst.conf_broadband "
SRC_URI:remove:broadband += " file://lighttpd_php.conf_broadband "

