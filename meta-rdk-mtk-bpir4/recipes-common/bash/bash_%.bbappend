SRC_URI:remove:class-nativesdk:wrynose = "file://bash_log.patch"
