INSANE_SKIP:${PN}:scarthgap += "file-rdeps"
