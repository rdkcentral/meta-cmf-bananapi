EXTRA_OECMAKE:append:wrynose = " -DCMAKE_POLICY_VERSION_MINIMUM=3.5 "
