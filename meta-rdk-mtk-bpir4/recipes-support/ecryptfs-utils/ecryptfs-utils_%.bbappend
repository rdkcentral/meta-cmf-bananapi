FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append:scarthgap = " file://typedef_error_scarthgap.patch"
