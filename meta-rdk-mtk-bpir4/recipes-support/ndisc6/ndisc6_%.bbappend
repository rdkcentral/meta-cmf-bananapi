FILES:${PN} += " ${bindir}/rdisc6"
