SYSTEMD_AUTO_ENABLE:${PN} = "disable"
ERROR_QA:remove = "patch-fuzz"
WARN_QA:append = " patch-fuzz"
