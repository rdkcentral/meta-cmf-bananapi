SRC_URI:remove:wrynose = "file://0001-esdk-cert-path-issue_kirkstone.patch"
