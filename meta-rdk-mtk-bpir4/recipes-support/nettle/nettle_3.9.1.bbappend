EXTRA_OECONF:append = " --enable-shared --disable-static"
