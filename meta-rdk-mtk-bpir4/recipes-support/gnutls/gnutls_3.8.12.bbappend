PACKAGECONFIG:remove:class-nativesdk:wrynose = "libtasn1"
