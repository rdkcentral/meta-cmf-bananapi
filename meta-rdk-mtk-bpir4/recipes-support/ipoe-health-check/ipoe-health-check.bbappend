LDFLAGS = " -lmsgpackc"

