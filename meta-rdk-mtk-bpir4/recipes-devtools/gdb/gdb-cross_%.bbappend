PACKAGECONFIG:remove:wrynose = "readline"
