PACKAGECONFIG:remove:class-nativesdk:wrynose = "gdbm"
