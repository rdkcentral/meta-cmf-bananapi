RDEPENDS:${PN}:remove:wrynose = "gettext-dev"
