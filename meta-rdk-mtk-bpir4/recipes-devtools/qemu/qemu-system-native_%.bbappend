PACKAGECONFIG:remove = "virglrenderer"
