RDEPENDS:${PN}:remove:wrynose = "nativesdk-elfutils"
RDEPENDS:${PN}:append:wrynose = " nativesdk-libelf nativesdk-libdw"
