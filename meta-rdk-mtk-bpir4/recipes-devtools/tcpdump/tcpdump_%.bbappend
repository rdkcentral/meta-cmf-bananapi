# RDKBACCL-2234: keep tcpdump in rootfs on BPI. Overrides the rm added by RDKB-65729 (ff5fd1b)
pkg_postinst_${PN}-dl () {
    :
}
