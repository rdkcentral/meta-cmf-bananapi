
PACKAGECONFIG:remove = "elf"
