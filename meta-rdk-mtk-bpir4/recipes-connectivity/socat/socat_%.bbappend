EXTRA_OECONF:remove = " --disable-proxy \
                --disable-tun \
                --disable-stdio \
                --disable-sctp \
                --disable-socks4 \
                --disable-socks4a \
                --disable-udp \
                --disable-fdnum \
                --disable-creat \
                --disable-gopen \
                --disable-pipe \
                --disable-unix \
                --disable-abstract-unixsocket \
                --disable-rawip \
                --disable-genericsocket \
                --disable-system \
                --disable-readline \
"

