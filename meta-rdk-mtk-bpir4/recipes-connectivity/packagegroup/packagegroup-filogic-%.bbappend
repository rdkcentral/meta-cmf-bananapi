RDEPENDS_packagegroup-filogic-logan_remove += " iwinfo \
                                             uci \
"
RDEPENDS_packagegroup-filogic-mt76_remove += " iwinfo \
                                          uci \
"

