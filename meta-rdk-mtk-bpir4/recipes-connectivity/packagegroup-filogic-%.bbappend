RDEPENDS_packagegroup-filogic-logan_remove = " iwinfo"
RDEPENDS_packagegroup-filogic-mt76_remove = " iwinfo"

