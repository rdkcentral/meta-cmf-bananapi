SRCREV = "${SRCREV_kernel6-6}"
