DEPENDS_remove = "hal-cm hal-moca hal-mso_mgmt hal-mta"
