include ccsp_common_bananapi.inc
DEPENDS_remove = "hal-cm"
