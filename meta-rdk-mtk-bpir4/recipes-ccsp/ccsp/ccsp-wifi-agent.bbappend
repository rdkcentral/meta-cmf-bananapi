CFLAGS_append = " -D_PLATFORM_BANANAPI_R4_  -D_WIFI_AX_SUPPORT_ "
