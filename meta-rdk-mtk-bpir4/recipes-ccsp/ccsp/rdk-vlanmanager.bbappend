include ccsp_common_bananapi.inc
TARGET_CFLAGS += "-Wno-error=address"
