DEPENDS_remove = "hal-cm"
