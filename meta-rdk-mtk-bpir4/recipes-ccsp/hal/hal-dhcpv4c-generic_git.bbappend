SRC_URI_remove = "git://git01.mediatek.com/filogic/rdk-b/rdkb_hal;protocol=https;destsuffix=git/source/dhcpv4c/rdkb_hal;branch=master"
SRC_URI += "git://github.com/mediatek/rdkb_hal;protocol=https;destsuffix=git/source/dhcpv4c/rdkb_hal;branch=main"
