FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://rdkbaccl-2084-firmware-name-length.patch"
