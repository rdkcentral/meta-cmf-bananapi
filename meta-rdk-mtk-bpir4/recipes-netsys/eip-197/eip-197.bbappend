SRC_URI:remove = "git://git01.mediatek.com/openwrt/feeds/mtk-openwrt-feeds;protocol=https;branch=master;destsuffix=git"
SRC_URI:append = " git://github.com/mediatek/mtk-openwrt-feeds;protocol=https;branch=main;destsuffix=git"
